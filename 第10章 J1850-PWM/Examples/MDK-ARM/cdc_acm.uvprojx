# Keil uVision project cdc_acm.uvprojx, settings and files
target J1850-PWM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: cdc_acm +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X,USE_USB_FS  GD32C103V_EVAL USE_IRC48M
  c misc: --c99
  c include: ..\inc;..\..\Firmware\CMSIS\GD\GD32C10x\Include;..\..\Firmware\GD32C10x_standard_peripheral\Include;..\..\Firmware\GD32C10x_usbfs_library\driver\Include;..\..\Firmware\GD32C10x_usbfs_library\device\core\Include;..\..\Firmware\GD32C10x_usbfs_library\device\class\cdc\Include;..\..\Firmware\GD32C10x_usbfs_library\ustd\common;..\..\Firmware\GD32C10x_usbfs_library\ustd\class\cdc;..\..\Utilities;..\..\BSP;..\..\Firmware\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c gd32c10x_hw.c gd32c10x_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group GD32C10x_StdPeriph_Driver
    ../../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
  group GD32C10x_EVAL
    ../../Utilities/: gd32c10x_eval.c
  group USB_Drivers
    ../../Firmware/GD32C10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../Firmware/GD32C10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../Firmware/GD32C10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
  group BSP
    ../../BSP/: bsp.c can.c timer.c usart.c vpwm.c
  group Doc
    ../: readme.txt
